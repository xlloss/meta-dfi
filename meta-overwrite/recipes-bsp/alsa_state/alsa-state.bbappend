# sgtl-5000 audio codec asound.state file
FILESEXTRAPATHS_prepend_mx8 := "${THISDIR}/files:"
