FILESEXTRAPATHS_append_mx8 := "${THISDIR}/files:"


SRC_URI += " file://0001-auto-find-platform-dtb-avoid-build-fail.patch \
"

