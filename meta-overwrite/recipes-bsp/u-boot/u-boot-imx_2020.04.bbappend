FILESEXTRAPATHS_prepend_mx8 := "${THISDIR}/files:"


SRC_URI += "file://dfi_release_uboot_2021_01_26.patch \
            file://dfi_release_uboot_2021_04_15.patch \
            file://dfi_release_uboot_2021_08_13.patch \
            file://dfi_release_uboot_2021_12_17.patch \
            file://dfi_release_uboot_2022_01_06.patch \
            file://dfi_release_uboot_2022_01_17.patch \
	    file://dfi_release_uboot_2022_02_15.patch \
	    file://dfi_release_uboot_2022_02_17.patch \
"
